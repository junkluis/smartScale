# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ../../touchgfx/framework/include;../../gui/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/stm32f7xx;../bsp/include/platform/stm32f7xx/CMSIS;../bsp/include/platform/stm32f7xx/STM32F7xx_HAL_Driver;../bsp/include;../bsp/include/vendor;../bsp/source/vendor/STM32746G-Discovery;../os/FreeRTOS8.2.0/Source/include;../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7
  asm include: ../os/FreeRTOSV8.2.0/FreeRTOS/Source/include;../os/FreeRTOSV8.2.0/FreeRTOS/Source/portable/RVDS/ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../bsp/source/platform/stm32f7xx/Keil/: startup_stm32f746xx.s
  group TouchGFXHAL
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/common/: customkeyboard.cpp frontendapplication.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../../gui/src/screensaver_screen/: screensaverpresenter.cpp screensaverview.cpp
    ../../gui/src/teclado_screen/: tecladopresenter.cpp tecladoview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp font_fradm_ttf_18_4bpp.cpp font_verdana_10_4bpp.cpp font_verdana_20_4bpp.cpp font_verdana_24_4bpp.cpp font_verdana_28_4bpp.cpp font_verdana_40_4bpp.cpp font_verdanab_24_4bpp.cpp fontgetters.cpp kerning_fradm_ttf_18_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_24_4bpp.cpp kerning_verdana_28_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdanab_24_4bpp.cpp table_fradm_ttf_18_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_24_4bpp.cpp table_verdana_28_4bpp.cpp table_verdana_40_4bpp.cpp table_verdanab_24_4bpp.cpp
    ../../generated/images/src/: background-title.cpp bitmapdatabase.cpp btn-ok-pressed.cpp btn-ok.cpp btn-pressed.cpp btn.cpp icon_keyboard_even_row.cpp icon_keyboard_highlighted.cpp icon_keyboard_odd_row.cpp keyboard_background.cpp keyboard_key_delete_highlighted.cpp keyboard_key_highlighted.cpp keyboard_key_num_highlighted.cpp keyboard_key_shift_highlighted.cpp keyboard_space_highlighted.cpp screensaver.cpp text-field.cpp
    ../../generated/images/src/__designer/: blue_backgrounds_main_bg_480x272px.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../../generated/gui_generated/src/screensaver_screen/: screensaverviewbase.cpp
    ../../generated/gui_generated/src/teclado_screen/: tecladoviewbase.cpp
